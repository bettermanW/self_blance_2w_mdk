# Keil uVision project self_blance_mdk.uvprojx, settings and files
target self_driver_car2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: self_blance_mdk +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\LIbrarics\STM32F10x_StdPeriph_Driver\inc;..\LIbrarics\CMSIS\CM3\CoreSupport;..\LIbrarics\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\LIbrarics\STM32F10x_StdPeriph_Driver\inc;..\Driver;..\User;..\Driver\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../LIbrarics/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../LIbrarics/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../LIbrarics/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FWLB
    ../LIbrarics/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c test.c blance.c blance.h stm32f10x_it.c
  group DRIVER
    ../Driver/: led.c led.h sys.h key.h key.c delay.h delay.c dr_uart.h dr_uart.c vin.h vin.c buzzer.h buzzer.c motor.h motor.c encoder.h encoder.c soft_i2c.h soft_i2c.c mpu6050.h mpu6050.c
    ../Driver/oled/: font.c oled.c
